<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>echo_wrapper_neural</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N0</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>body</value></param>
<param><key>value</key><value>[1,1,1,1,1,1,1,0,0,1,1,0,0,0,0,1,0,1,1,1,0,1,1,1,1,0,0,1,0,0,1,0,1,0,1,0,1,1,0,1,1,0,0,1,0,0,1,0,0,0,0,0,1,0,0,1,0,0,0,1,1,0,0,0,1,0,0,0,0,1,1,1,1,0,1,1,0,1,0,1,1,0,1,1,1,1,0,1,0,0,0,0,0,0,0,0,0,1,0,1,1,1,1,0,1,0,0,1,1,1,1,1,1,0,1,1,1,0,0,0,1,1,1,1,1,0,1,0,0,0,0,0,1,0,1,0,0,1,0,1,0,1,1,1,1,0,0,1,0,1,1,0,0,1,1,1,0,1,0,0,0,1,0,1,0,1,0,0,1,1,0,1,1,0,1,0,0,0,0,0,0,1,1,0,0,0,0,1,0,0,0,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,0,0,1,1,1,0,0,0,0,1,0,1,1,0,1,1,1,0,0,0,1,1,1,1,1,0,1,1,1,0,0,1,0,1,1,0,1,0,1,0,0,0,0,1,1,1,0,1,0,0,0,1,1,1,0,1,0,0,0,0,1,1,0,0,1,1,0,0,1,1,1,0,0,0,1,1,0,0,1,1,0,1,0,1,0,1,0,1,0,0,0,1,1,0,1,1,1,0,0,1,1,1,1,1,0,0,1,0,0,1,0,1,0,1,0,0,1,0,0,1,0,1,0,1,1,1,0,0,1,0,1,1,1,0,1,1,0,1,0,1,1,1,1,1,0,1,1,1,0,1,0,1,0,1,0,0,0,1,0,1,1,0,1,0,1,1,1,1,1,1,0,1,1,0,0,0,1,0,0,1,1,1,1,0,0,1,0,0,0,0,1,0,0,1,0,1,0,0,0,0,1,1,1,1,0,0,0,1,0,0,1,0,1,1,0,1,0,1,0,1,0,1,0,0,0,0,1,1,0,1,0,1,1,0,0,1,0,1,1,1,1,0,1,1,0,0,0,0,1,1,0,0,0,0,1,1,0,1,0,1,0,0,0,0,1,1,0,0,0,1,0,0,1,0,1,0,0,0,1,0,1,1,0,1,1,1,1,1,1,0,0,1,0,0,1,0,0,1,0,0,0,0,1,1,0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cfo_freqs</value></param>
<param><key>value</key><value>11./256, 43./256, 97./256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>beta_rrc</value></param>
<param><key>label</key><value>RRC Beta</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.13</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bits_per_symb</value></param>
<param><key>label</key><value>Bits Per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>pkt</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>1152 * 2, 5000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_1</value></param>
<param><key>lengths</key><value>1152 * 2, 5000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>pkt</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfar_thresh</value></param>
<param><key>label</key><value>CFAR Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfo_samps</value></param>
<param><key>label</key><value>CFO Samples</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1</value></param>
<param><key>freq_offset</key><value>0.0000</value></param>
<param><key>noise_voltage</key><value>N0</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>0.714 + 0.714j</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0_0</value></param>
<param><key>epsilon</key><value>1</value></param>
<param><key>freq_offset</key><value>0.000</value></param>
<param><key>noise_voltage</key><value>N0</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>0.714+0.714j</value></param>
</block>
<block>
<key>echo_packet_handler</key>
<param><key>id</key><value>classic_to_neural_handler</value></param>
<param><key>beta_rrc</key><value>beta_rrc</value></param>
<param><key>body_size</key><value>2 * packet_len / samps_per_symb</value></param>
<param><key>cfar_thresh</key><value>cfar_thresh</value></param>
<param><key>cfo_freqs</key><value>cfo_freqs</value></param>
<param><key>cfo_samps</key><value>cfo_samps</value></param>
<param><key>corr_reps</key><value>corr_reps</value></param>
<param><key>samps_per_symb</key><value>samps_per_symb</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>corr_reps</value></param>
<param><key>label</key><value>Correlator Repetitions</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>log_interval</value></param>
<param><key>label</key><value>Constellation Log Interval</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>echo_packet_handler</key>
<param><key>id</key><value>neural_to_classic_handler</value></param>
<param><key>beta_rrc</key><value>beta_rrc</value></param>
<param><key>body_size</key><value>packet_len / samps_per_symb * 2</value></param>
<param><key>cfar_thresh</key><value>cfar_thresh</value></param>
<param><key>cfo_freqs</key><value>cfo_freqs</value></param>
<param><key>cfo_samps</key><value>cfo_samps</value></param>
<param><key>corr_reps</key><value>corr_reps</value></param>
<param><key>samps_per_symb</key><value>samps_per_symb</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>label</key><value>Packet Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"Detected Body Constellation"</value></param>
<param><key>size</key><value>packet_len / bits_per_symb * 2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"Channel IQ Scatter"</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samps_per_symb</value></param>
<param><key>label</key><value>Samples Per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>echo_demodulator_classic</key>
<param><key>id</key><value>echo_demodulator_classic_0</value></param>
<param><key>bits_per_symbol</key><value>bits_per_symb</value></param>
<param><key>block_length</key><value>1024</value></param>
<param><key>log_ber_interval</key><value>log_interval</value></param>
<param><key>preamble</key><value>body</value></param>
</block>
<block>
<key>echo_demodulator_classic</key>
<param><key>id</key><value>echo_demodulator_classic_0_0</value></param>
<param><key>bits_per_symbol</key><value>bits_per_symb</value></param>
<param><key>block_length</key><value>1024</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>log_ber_interval</key><value>log_interval</value></param>
<param><key>preamble</key><value>body</value></param>
</block>
<block>
<key>echo_demodulator_neural</key>
<param><key>id</key><value>echo_demodulator_neural_0</value></param>
<param><key>bits_per_symbol</key><value>bits_per_symb</value></param>
<param><key>log_constellation_interval</key><value>log_interval</value></param>
<param><key>hidden_layers</key><value>50</value></param>
<param><key>init_weights</key><value></value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>seed</key><value>134214</value></param>
</block>
<block>
<key>echo_modulator_classic</key>
<param><key>id</key><value>echo_modulator_classic_0</value></param>
<param><key>log_interval</key><value>log_interval</value></param>
<param><key>bits_per_symb</key><value>bits_per_symb</value></param>
<param><key>preamble</key><value>body</value></param>
</block>
<block>
<key>echo_modulator_classic</key>
<param><key>id</key><value>echo_modulator_classic_1</value></param>
<param><key>log_interval</key><value>log_interval</value></param>
<param><key>bits_per_symb</key><value>bits_per_symb</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>preamble</key><value>body</value></param>
</block>
<block>
<key>echo_modulator_neural</key>
<param><key>id</key><value>echo_modulator_neural_0</value></param>
<param><key>bits_per_symbol</key><value>bits_per_symb</value></param>
<param><key>log_constellation_interval</key><value>log_interval</value></param>
<param><key>hidden_layers</key><value>50</value></param>
<param><key>init_weights</key><value></value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>seed</key><value>12348907843</value></param>
</block>
<block>
<key>echo_packet_length_check</key>
<param><key>id</key><value>echo_packet_length_check_0</value></param>
<param><key>length</key><value>packet_len / bits_per_symb * 2</value></param>
</block>
<block>
<key>echo_packet_length_check</key>
<param><key>id</key><value>echo_packet_length_check_0_0</value></param>
<param><key>length</key><value>packet_len / bits_per_symb * 2</value></param>
</block>
<block>
<key>echo_preamble_insert</key>
<param><key>id</key><value>echo_preamble_insert_0</value></param>
<param><key>add_head</key><value>1</value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>rm_head</key><value>0</value></param>
<param><key>rm_tail</key><value>1</value></param>
</block>
<block>
<key>echo_preamble_insert</key>
<param><key>id</key><value>echo_preamble_insert_0_0</value></param>
<param><key>add_head</key><value>0</value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>rm_head</key><value>1</value></param>
<param><key>rm_tail</key><value>0</value></param>
</block>
<block>
<key>echo_preamble_insert</key>
<param><key>id</key><value>echo_preamble_insert_1</value></param>
<param><key>add_head</key><value>0</value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>rm_head</key><value>1</value></param>
<param><key>rm_tail</key><value>0</value></param>
</block>
<block>
<key>echo_preamble_insert</key>
<param><key>id</key><value>echo_preamble_insert_1_0</value></param>
<param><key>add_head</key><value>1</value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>rm_head</key><value>0</value></param>
<param><key>rm_tail</key><value>1</value></param>
</block>
<block>
<key>echo_triggered_vector_source_b</key>
<param><key>id</key><value>echo_triggered_vector_source_b_0</value></param>
<param><key>data</key><value>body * 2</value></param>
<param><key>initial_trigger</key><value>1</value></param>
<param><key>tag_key</key><value>pkt</value></param>
<param><key>triggers</key><value></value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_1</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1</source_block_id><sink_block_id>channels_channel_model_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>echo_modulator_classic_1</sink_block_id><source_key>pdus</source_key><sink_key>bits</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>echo_modulator_neural_0</sink_block_id><source_key>pdus</source_key><sink_key>bits</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>neural_to_classic_handler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0_0</source_block_id><sink_block_id>classic_to_neural_handler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classic_to_neural_handler</source_block_id><sink_block_id>echo_packet_length_check_0</sink_block_id><source_key>unwrap_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>classic_to_neural_handler</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>neural_to_classic_handler</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_1</sink_block_id><source_key>unwrap_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>neural_to_classic_handler</source_block_id><sink_block_id>echo_packet_length_check_0_0</sink_block_id><source_key>unwrap_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>neural_to_classic_handler</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>echo_demodulator_classic_0</source_block_id><sink_block_id>echo_preamble_insert_0</sink_block_id><source_key>bits</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>echo_demodulator_classic_0</source_block_id><sink_block_id>echo_preamble_insert_0_0</sink_block_id><source_key>bits</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>echo_demodulator_classic_0_0</source_block_id><sink_block_id>echo_preamble_insert_1</sink_block_id><source_key>bits</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>echo_demodulator_neural_0</source_block_id><sink_block_id>echo_preamble_insert_1</sink_block_id><source_key>bits</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>echo_demodulator_neural_0</source_block_id><sink_block_id>echo_preamble_insert_1_0</sink_block_id><source_key>bits</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>echo_modulator_classic_0</source_block_id><sink_block_id>classic_to_neural_handler</sink_block_id><source_key>symbols</source_key><sink_key>wrap_in</sink_key></connection>
<connection><source_block_id>echo_modulator_classic_1</source_block_id><sink_block_id>neural_to_classic_handler</sink_block_id><source_key>symbols</source_key><sink_key>wrap_in</sink_key></connection>
<connection><source_block_id>echo_modulator_neural_0</source_block_id><sink_block_id>neural_to_classic_handler</sink_block_id><source_key>symbols</source_key><sink_key>wrap_in</sink_key></connection>
<connection><source_block_id>echo_packet_length_check_0</source_block_id><sink_block_id>echo_triggered_vector_source_b_0</sink_block_id><source_key>failed</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>echo_packet_length_check_0</source_block_id><sink_block_id>echo_demodulator_classic_0_0</sink_block_id><source_key>validated</source_key><sink_key>symbols</sink_key></connection>
<connection><source_block_id>echo_packet_length_check_0</source_block_id><sink_block_id>echo_demodulator_neural_0</sink_block_id><source_key>validated</source_key><sink_key>symbols</sink_key></connection>
<connection><source_block_id>echo_packet_length_check_0_0</source_block_id><sink_block_id>echo_triggered_vector_source_b_0</sink_block_id><source_key>failed</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>echo_packet_length_check_0_0</source_block_id><sink_block_id>echo_demodulator_classic_0</sink_block_id><source_key>validated</source_key><sink_key>symbols</sink_key></connection>
<connection><source_block_id>echo_preamble_insert_0</source_block_id><sink_block_id>echo_modulator_classic_0</sink_block_id><source_key>out</source_key><sink_key>bits</sink_key></connection>
<connection><source_block_id>echo_preamble_insert_0_0</source_block_id><sink_block_id>echo_modulator_classic_0</sink_block_id><source_key>out</source_key><sink_key>update</sink_key></connection>
<connection><source_block_id>echo_preamble_insert_1</source_block_id><sink_block_id>echo_modulator_neural_0</sink_block_id><source_key>out</source_key><sink_key>feedback</sink_key></connection>
<connection><source_block_id>echo_preamble_insert_1_0</source_block_id><sink_block_id>echo_modulator_neural_0</sink_block_id><source_key>out</source_key><sink_key>bits</sink_key></connection>
<connection><source_block_id>echo_triggered_vector_source_b_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
