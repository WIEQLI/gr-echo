<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>echo_neural_usrp_loop_nospy</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>F_center</value></param>
<param><key>value</key><value>1000000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>body</value></param>
<param><key>value</key><value>[1,1,1,1,1,1,1,0,0,1,1,0,0,0,0,1,0,1,1,1,0,1,1,1,1,0,0,1,0,0,1,0,1,0,1,0,1,1,0,1,1,0,0,1,0,0,1,0,0,0,0,0,1,0,0,1,0,0,0,1,1,0,0,0,1,0,0,0,0,1,1,1,1,0,1,1,0,1,0,1,1,0,1,1,1,1,0,1,0,0,0,0,0,0,0,0,0,1,0,1,1,1,1,0,1,0,0,1,1,1,1,1,1,0,1,1,1,0,0,0,1,1,1,1,1,0,1,0,0,0,0,0,1,0,1,0,0,1,0,1,0,1,1,1,1,0,0,1,0,1,1,0,0,1,1,1,0,1,0,0,0,1,0,1,0,1,0,0,1,1,0,1,1,0,1,0,0,0,0,0,0,1,1,0,0,0,0,1,0,0,0,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,0,0,1,1,1,0,0,0,0,1,0,1,1,0,1,1,1,0,0,0,1,1,1,1,1,0,1,1,1,0,0,1,0,1,1,0,1,0,1,0,0,0,0,1,1,1,0,1,0,0,0,1,1,1,0,1,0,0,0,0,1,1,0,0,1,1,0,0,1,1,1,0,0,0,1,1,0,0,1,1,0,1,0,1,0,1,0,1,0,0,0,1,1,0,1,1,1,0,0,1,1,1,1,1,0,0,1,0,0,1,0,1,0,1,0,0,1,0,0,1,0,1,0,1,1,1,0,0,1,0,1,1,1,0,1,1,0,1,0,1,1,1,1,1,0,1,1,1,0,1,0,1,0,1,0,0,0,1,0,1,1,0,1,0,1,1,1,1,1,1,0,1,1,0,0,0,1,0,0,1,1,1,1,0,0,1,0,0,0,0,1,0,0,1,0,1,0,0,0,0,1,1,1,1,0,0,0,1,0,0,1,0,1,1,0,1,0,1,0,1,0,1,0,0,0,0,1,1,0,1,0,1,1,0,0,1,0,1,1,1,1,0,1,1,0,0,0,0,1,1,0,0,0,0,1,1,0,1,0,1,0,0,0,0,1,1,0,0,0,1,0,0,1,0,1,0,0,0,1,0,1,1,0,1,1,1,1,1,1,0,0,1,0,0,1,0,0,1,0,0,0,0,1,1,0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cfo_freqs</value></param>
<param><key>value</key><value>11./256, 43./256, 97./256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>beta_rrc</value></param>
<param><key>label</key><value>RRC Beta</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.13</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bits_per_symb</value></param>
<param><key>label</key><value>Bits Per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>pkt</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>pkt</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>pkt</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>pkt</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfar_thresh</value></param>
<param><key>label</key><value>CFAR Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfo_samps</value></param>
<param><key>label</key><value>CFO Samples</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>corr_reps</value></param>
<param><key>label</key><value>Correlator Repetitions</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>log_interval</value></param>
<param><key>label</key><value>Constellation Log Interval</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>echo_packet_handler</key>
<param><key>id</key><value>neural_to_classic_handler</value></param>
<param><key>beta_rrc</key><value>beta_rrc</value></param>
<param><key>body_size</key><value>(2 * packet_len + spy_length) / bits_per_symb</value></param>
<param><key>cfar_thresh</key><value>cfar_thresh</value></param>
<param><key>cfo_freqs</key><value>cfo_freqs</value></param>
<param><key>cfo_samps</key><value>cfo_samps</value></param>
<param><key>corr_reps</key><value>corr_reps</value></param>
<param><key>samps_per_symb</key><value>samps_per_symb</value></param>
</block>
<block>
<key>echo_packet_handler</key>
<param><key>id</key><value>neural_to_classic_handler_0</value></param>
<param><key>beta_rrc</key><value>beta_rrc</value></param>
<param><key>body_size</key><value>(2 * packet_len + spy_length) / bits_per_symb</value></param>
<param><key>cfar_thresh</key><value>cfar_thresh</value></param>
<param><key>cfo_freqs</key><value>cfo_freqs</value></param>
<param><key>cfo_samps</key><value>cfo_samps</value></param>
<param><key>corr_reps</key><value>corr_reps</value></param>
<param><key>samps_per_symb</key><value>samps_per_symb</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>label</key><value>Packet Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"Detected Body Constellation"</value></param>
<param><key>size</key><value>(2 * packet_len + spy_length) / bits_per_symb</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"Channel IQ Scatter"</value></param>
<param><key>size</key><value>(2 * packet_len + spy_length) / bits_per_symb</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samps_per_symb</value></param>
<param><key>label</key><value>Samples Per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spy_length</value></param>
<param><key>label</key><value>Spy Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spy_thresh</value></param>
<param><key>label</key><value>Spy Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>echo_demodulator_classic_spy</key>
<param><key>id</key><value>echo_demodulator_classic_spy_0</value></param>
<param><key>bits_per_symbol</key><value>bits_per_symb</value></param>
<param><key>block_length</key><value>1024</value></param>
<param><key>log_ber_interval</key><value>log_interval</value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>spy_length</key><value>spy_length</value></param>
<param><key>spy_threshold</key><value>spy_thresh</value></param>
</block>
<block>
<key>echo_demodulator_classic_spy</key>
<param><key>id</key><value>echo_demodulator_classic_spy_0_0</value></param>
<param><key>bits_per_symbol</key><value>bits_per_symb</value></param>
<param><key>block_length</key><value>1024</value></param>
<param><key>log_ber_interval</key><value>log_interval</value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>spy_length</key><value>spy_length</value></param>
<param><key>spy_threshold</key><value>spy_thresh</value></param>
</block>
<block>
<key>echo_demodulator_neural_spy</key>
<param><key>id</key><value>echo_demodulator_neural_spy_0</value></param>
<param><key>bits_per_symbol</key><value>bits_per_symb</value></param>
<param><key>log_constellation_interval</key><value>log_interval</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>hidden_layers</key><value>20</value></param>
<param><key>init_weights</key><value></value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>seed</key><value>134214</value></param>
<param><key>spy_length</key><value>spy_length</value></param>
<param><key>spy_threshold</key><value>spy_thresh</value></param>
</block>
<block>
<key>echo_modulator_classic_spy</key>
<param><key>id</key><value>echo_modulator_classic_spy_0</value></param>
<param><key>log_interval</key><value>log_interval</value></param>
<param><key>bits_per_symb</key><value>bits_per_symb</value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>spy_length</key><value>spy_length</value></param>
</block>
<block>
<key>echo_modulator_classic_spy</key>
<param><key>id</key><value>echo_modulator_classic_spy_0_0</value></param>
<param><key>log_interval</key><value>log_interval</value></param>
<param><key>bits_per_symb</key><value>bits_per_symb</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>spy_length</key><value>spy_length</value></param>
</block>
<block>
<key>echo_modulator_neural</key>
<param><key>id</key><value>echo_modulator_neural_0</value></param>
<param><key>bits_per_symbol</key><value>bits_per_symb</value></param>
<param><key>log_constellation_interval</key><value>log_interval</value></param>
<param><key>hidden_layers</key><value>[20]</value></param>
<param><key>init_weights</key><value></value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>seed</key><value>65362</value></param>
</block>
<block>
<key>echo_modulator_neural_spy</key>
<param><key>id</key><value>echo_modulator_neural_spy_0</value></param>
<param><key>bits_per_symbol</key><value>bits_per_symb</value></param>
<param><key>log_constellation_interval</key><value>log_interval</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>hidden_layers</key><value>1</value></param>
<param><key>init_weights</key><value></value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>seed</key><value>123489</value></param>
<param><key>spy_length</key><value>spy_length</value></param>
</block>
<block>
<key>echo_packet_length_check</key>
<param><key>id</key><value>echo_packet_length_check_0</value></param>
<param><key>length</key><value>(2 * packet_len + spy_length) / bits_per_symb</value></param>
</block>
<block>
<key>echo_packet_length_check</key>
<param><key>id</key><value>echo_packet_length_check_0_0</value></param>
<param><key>length</key><value>(2 * packet_len + spy_length) / bits_per_symb</value></param>
</block>
<block>
<key>echo_preamble_insert</key>
<param><key>id</key><value>echo_preamble_insert_0_0</value></param>
<param><key>add_head</key><value>1</value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>rm_head</key><value>0</value></param>
<param><key>rm_tail</key><value>0</value></param>
</block>
<block>
<key>echo_preamble_insert</key>
<param><key>id</key><value>echo_preamble_insert_0_0_1</value></param>
<param><key>add_head</key><value>0</value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>rm_head</key><value>1</value></param>
<param><key>rm_tail</key><value>0</value></param>
</block>
<block>
<key>echo_preamble_insert</key>
<param><key>id</key><value>echo_preamble_insert_0_1</value></param>
<param><key>add_head</key><value>1</value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>rm_head</key><value>0</value></param>
<param><key>rm_tail</key><value>1</value></param>
</block>
<block>
<key>echo_preamble_insert</key>
<param><key>id</key><value>echo_preamble_insert_0_1_0</value></param>
<param><key>add_head</key><value>1</value></param>
<param><key>preamble</key><value>body</value></param>
<param><key>rm_head</key><value>0</value></param>
<param><key>rm_tail</key><value>0</value></param>
</block>
<block>
<key>echo_triggered_vector_source_b</key>
<param><key>id</key><value>echo_triggered_vector_source_b_0</value></param>
<param><key>data</key><value>body</value></param>
<param><key>initial_trigger</key><value>1</value></param>
<param><key>tag_key</key><value>pkt</value></param>
<param><key>triggers</key><value></value></param>
</block>
<block>
<key>echo_triggered_vector_source_b</key>
<param><key>id</key><value>echo_triggered_vector_source_b_0_0</value></param>
<param><key>data</key><value>body</value></param>
<param><key>initial_trigger</key><value>1</value></param>
<param><key>tag_key</key><value>pkt</value></param>
<param><key>triggers</key><value></value></param>
</block>
<block>
<key>echo_watchdog</key>
<param><key>id</key><value>echo_watchdog_0</value></param>
<param><key>timeout</key><value>5</value></param>
</block>
<block>
<key>echo_watchdog</key>
<param><key>id</key><value>echo_watchdog_0_0</value></param>
<param><key>timeout</key><value>5</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>F_center</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>F_center</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value>packet_len</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>F_center</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>ant1</key><value>RX2</value></param>
<param><key>center_freq1</key><value>F_center</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_1</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_1_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>echo_preamble_insert_0_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0_0</source_block_id><sink_block_id>echo_preamble_insert_0_1_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>neural_to_classic_handler</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_1_0</sink_block_id><source_key>unwrap_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>neural_to_classic_handler</source_block_id><sink_block_id>echo_packet_length_check_0</sink_block_id><source_key>unwrap_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>neural_to_classic_handler</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>neural_to_classic_handler_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_1</sink_block_id><source_key>unwrap_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>neural_to_classic_handler_0</source_block_id><sink_block_id>echo_packet_length_check_0_0</sink_block_id><source_key>unwrap_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>neural_to_classic_handler_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>echo_demodulator_classic_spy_0</source_block_id><sink_block_id>echo_preamble_insert_0_0_1</sink_block_id><source_key>bits</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>echo_demodulator_classic_spy_0</source_block_id><sink_block_id>echo_preamble_insert_0_1</sink_block_id><source_key>bits</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>echo_demodulator_classic_spy_0</source_block_id><sink_block_id>echo_triggered_vector_source_b_0_0</sink_block_id><source_key>corrupt</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>echo_demodulator_classic_spy_0_0</source_block_id><sink_block_id>echo_modulator_neural_0</sink_block_id><source_key>bits</source_key><sink_key>feedback</sink_key></connection>
<connection><source_block_id>echo_demodulator_classic_spy_0_0</source_block_id><sink_block_id>echo_triggered_vector_source_b_0</sink_block_id><source_key>corrupt</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>echo_demodulator_neural_spy_0</source_block_id><sink_block_id>echo_triggered_vector_source_b_0</sink_block_id><source_key>corrupt</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>echo_modulator_classic_spy_0</source_block_id><sink_block_id>neural_to_classic_handler_0</sink_block_id><source_key>symbols</source_key><sink_key>wrap_in</sink_key></connection>
<connection><source_block_id>echo_modulator_classic_spy_0_0</source_block_id><sink_block_id>neural_to_classic_handler</sink_block_id><source_key>symbols</source_key><sink_key>wrap_in</sink_key></connection>
<connection><source_block_id>echo_modulator_neural_0</source_block_id><sink_block_id>neural_to_classic_handler</sink_block_id><source_key>symbols</source_key><sink_key>wrap_in</sink_key></connection>
<connection><source_block_id>echo_modulator_neural_spy_0</source_block_id><sink_block_id>neural_to_classic_handler</sink_block_id><source_key>symbols</source_key><sink_key>wrap_in</sink_key></connection>
<connection><source_block_id>echo_packet_length_check_0</source_block_id><sink_block_id>echo_triggered_vector_source_b_0</sink_block_id><source_key>failed</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>echo_packet_length_check_0</source_block_id><sink_block_id>echo_watchdog_0</sink_block_id><source_key>passthrough</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>echo_packet_length_check_0</source_block_id><sink_block_id>echo_demodulator_classic_spy_0_0</sink_block_id><source_key>validated</source_key><sink_key>symbols</sink_key></connection>
<connection><source_block_id>echo_packet_length_check_0</source_block_id><sink_block_id>echo_demodulator_neural_spy_0</sink_block_id><source_key>validated</source_key><sink_key>symbols</sink_key></connection>
<connection><source_block_id>echo_packet_length_check_0_0</source_block_id><sink_block_id>echo_triggered_vector_source_b_0_0</sink_block_id><source_key>failed</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>echo_packet_length_check_0_0</source_block_id><sink_block_id>echo_watchdog_0_0</sink_block_id><source_key>passthrough</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>echo_packet_length_check_0_0</source_block_id><sink_block_id>echo_demodulator_classic_spy_0</sink_block_id><source_key>validated</source_key><sink_key>symbols</sink_key></connection>
<connection><source_block_id>echo_preamble_insert_0_0</source_block_id><sink_block_id>echo_modulator_classic_spy_0_0</sink_block_id><source_key>out</source_key><sink_key>bits</sink_key></connection>
<connection><source_block_id>echo_preamble_insert_0_0</source_block_id><sink_block_id>echo_modulator_neural_0</sink_block_id><source_key>out</source_key><sink_key>bits</sink_key></connection>
<connection><source_block_id>echo_preamble_insert_0_0</source_block_id><sink_block_id>echo_modulator_neural_spy_0</sink_block_id><source_key>out</source_key><sink_key>bits</sink_key></connection>
<connection><source_block_id>echo_preamble_insert_0_0_1</source_block_id><sink_block_id>echo_modulator_classic_spy_0</sink_block_id><source_key>out</source_key><sink_key>update</sink_key></connection>
<connection><source_block_id>echo_preamble_insert_0_1</source_block_id><sink_block_id>echo_modulator_classic_spy_0</sink_block_id><source_key>out</source_key><sink_key>bits</sink_key></connection>
<connection><source_block_id>echo_preamble_insert_0_1_0</source_block_id><sink_block_id>echo_modulator_classic_spy_0</sink_block_id><source_key>out</source_key><sink_key>bits</sink_key></connection>
<connection><source_block_id>echo_triggered_vector_source_b_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>echo_triggered_vector_source_b_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>echo_watchdog_0</source_block_id><sink_block_id>echo_triggered_vector_source_b_0</sink_block_id><source_key>out</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>echo_watchdog_0_0</source_block_id><sink_block_id>echo_triggered_vector_source_b_0_0</sink_block_id><source_key>out</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>neural_to_classic_handler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>neural_to_classic_handler_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
