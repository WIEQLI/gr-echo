<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>echo_single_usrp</value></param>
<param><key>author</key><value>Josh Sanz</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>Echo Single-USRP Flowgraph</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>F_center</value></param>
<param><key>value</key><value>1000000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cfo_freqs</value></param>
<param><key>value</key><value>11./256, 43./256, 97./256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>full_len</value></param>
<param><key>value</key><value>2 * packet_len + (spy_length + 96) / bits_per_symb</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spy_length</value></param>
<param><key>value</key><value>64 * bits_per_symb</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>beta_rrc</value></param>
<param><key>label</key><value>RRC Beta</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.13</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bits_per_symb</value></param>
<param><key>label</key><value>Bits Per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>iq-in.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>pkt</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>pkt</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0x01</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>2 * packet_len * bits_per_symb</value></param>
<param><key>minsize</key><value>2 * packet_len * bits_per_symb</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfar_thresh</value></param>
<param><key>label</key><value>CFAR Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfo_samps</value></param>
<param><key>label</key><value>CFO Samples</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>noise_voltage</key><value>0.0000</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 0.0j</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>corr_reps</value></param>
<param><key>label</key><value>Correlator Repetitions</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>demod_hidden_layers</value></param>
<param><key>label</key><value>Demod Hidden Layers</value></param>
<param><key>value</key><value>[50]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>demod_init_weights</value></param>
<param><key>label</key><value>Demodulator Init Weights</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>demod_seed</value></param>
<param><key>label</key><value>demod_seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>341133</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>demodtype</value></param>
<param><key>label</key><value>Demodulator Type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>neural</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lambda_center</value></param>
<param><key>label</key><value>Lambda Center</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>log_interval</value></param>
<param><key>label</key><value>Constellation Log Interval</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_amplitude</value></param>
<param><key>label</key><value>Max Amplitude</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.707</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mod_hidden_layers</value></param>
<param><key>label</key><value>Mod Hidden Layers</value></param>
<param><key>value</key><value>[50]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mod_init_weights</value></param>
<param><key>label</key><value>Modulator Init Weights</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mod_seed</value></param>
<param><key>label</key><value>mod_seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>341132</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>modtype</value></param>
<param><key>label</key><value>Modulator Type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>neural</value></param>
</block>
<block>
<key>echo_packet_handler</key>
<param><key>id</key><value>neural_to_classic_handler</value></param>
<param><key>beta_rrc</key><value>beta_rrc</value></param>
<param><key>body_size</key><value>full_len</value></param>
<param><key>cfar_thresh</key><value>cfar_thresh</value></param>
<param><key>cfo_freqs</key><value>cfo_freqs</value></param>
<param><key>cfo_samps</key><value>cfo_samps</value></param>
<param><key>corr_reps</key><value>corr_reps</value></param>
<param><key>samps_per_symb</key><value>samps_per_symb</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>label</key><value>Packet Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"Detected Body Constellation"</value></param>
<param><key>size</key><value>full_len</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"Transmitted Constellation"</value></param>
<param><key>size</key><value>full_len</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>rx_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samps_per_symb</value></param>
<param><key>label</key><value>Samples Per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>shared_preamble</value></param>
<param><key>label</key><value>Shared Preamble File</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spy_thresh</value></param>
<param><key>label</key><value>Spy Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>echo_echo_mod_demod</key>
<param><key>id</key><value>echo_echo_mod_demod_0</value></param>
<param><key>bits_per_symb</key><value>bits_per_symb</value></param>
<param><key>demod_hidden_layers</key><value>demod_hidden_layers</value></param>
<param><key>demod_init_weights</key><value>demod_init_weights</value></param>
<param><key>demod_seed</key><value>demod_seed</value></param>
<param><key>demodtype</key><value>demodtype</value></param>
<param><key>lambda_center</key><value>lambda_center</value></param>
<param><key>log_interval</key><value>log_interval</value></param>
<param><key>max_amplitude</key><value>max_amplitude</value></param>
<param><key>mod_hidden_layers</key><value>mod_hidden_layers</value></param>
<param><key>mod_init_weights</key><value>mod_init_weights</value></param>
<param><key>mod_seed</key><value>mod_seed</value></param>
<param><key>modtype</key><value>modtype</value></param>
<param><key>npreamble</key><value>packet_len * bits_per_symb</value></param>
<param><key>shared_preamble</key><value>shared_preamble</value></param>
<param><key>spy_length</key><value>spy_length</value></param>
<param><key>spy_threshold</key><value>0.1</value></param>
<param><key>_alias</key><value>neural-agent</value></param>
</block>
<block>
<key>echo_watchdog</key>
<param><key>id</key><value>echo_watchdog_0</value></param>
<param><key>timeout</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>label</key><value>tx_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>F_center</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value>packet_len</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>F_center</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>ant1</key><value>RX2</value></param>
<param><key>center_freq1</key><value>F_center</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>zeromq_pull_msg_source</key>
<param><key>id</key><value>zeromq_pull_msg_source_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5555</value></param>
<param><key>bind</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pull_msg_source</key>
<param><key>id</key><value>zeromq_pull_msg_source_1</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5556</value></param>
<param><key>bind</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_1</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_1_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>echo_echo_mod_demod_0</sink_block_id><source_key>pdus</source_key><sink_key>mod_in</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>neural_to_classic_handler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>neural_to_classic_handler</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_1</sink_block_id><source_key>unwrap_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>neural_to_classic_handler</source_block_id><sink_block_id>echo_echo_mod_demod_0</sink_block_id><source_key>unwrap_out</source_key><sink_key>demod_in</sink_key></connection>
<connection><source_block_id>neural_to_classic_handler</source_block_id><sink_block_id>echo_watchdog_0</sink_block_id><source_key>unwrap_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>neural_to_classic_handler</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>echo_echo_mod_demod_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_1_0</sink_block_id><source_key>mod_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>echo_echo_mod_demod_0</source_block_id><sink_block_id>neural_to_classic_handler</sink_block_id><source_key>mod_out</source_key><sink_key>wrap_in</sink_key></connection>
<connection><source_block_id>echo_watchdog_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>out</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_msg_source_0</source_block_id><sink_block_id>echo_echo_mod_demod_0</sink_block_id><source_key>out</source_key><sink_key>control</sink_key></connection>
<connection><source_block_id>zeromq_pull_msg_source_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>out</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>zeromq_pull_msg_source_1</source_block_id><sink_block_id>echo_echo_mod_demod_0</sink_block_id><source_key>out</source_key><sink_key>control</sink_key></connection>
<connection><source_block_id>zeromq_pull_msg_source_1</source_block_id><sink_block_id>uhd_usrp_source_0</sink_block_id><source_key>out</source_key><sink_key>command</sink_key></connection>
</flow_graph>
